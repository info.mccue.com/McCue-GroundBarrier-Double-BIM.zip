Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MCCUE_BIM_GBD-C-CNR-307.IFC
Time: 2025-01-23T14:25:36
Written by: SwIFC
Made in: SolidWorks 2024

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 17AA039-0.50 x 6.00 Concrete Anchor_5860 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 91294A360_Black-Oxide Alloy Steel Hex Drive Flat Head Screw_91294A360 (16)
In: Default Storey
PredefinedType: ELEMENT; Material: Plain Carbon Steel

# IfcBuildingElementProxy: 98688A121_General Purpose Zinc-Plated Steel Washer_98688A121 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Plain Carbon Steel

# IfcBuildingElementProxy: Boss-Extrude1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude1[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude2 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude3[2] (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude3[3] (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude3[4] (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss-Extrude5 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: CirPattern1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: CirPattern2[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: CirPattern2[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude12
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Revolve4 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet3 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: GBD-RLR
In: Default Storey
PredefinedType: ELEMENT; Material: PP Copolymer

# IfcBuildingElementProxy: HW-C-DPR_17AA013 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: POLYURETHANE (11671)

# IfcBuildingElementProxy: HW-C-IP-M16DPR (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Rubber

# IfcBuildingElementProxy: HW-C-IP-M16WSH (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Plain Carbon Steel

# IfcBuildingElementProxy: HW-C-WSH_17AA014 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Plain Carbon Steel

# IfcBuildingElementProxy: M12x1.75 Tapped Hole1[1] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: M12x1.75 Tapped Hole1[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: M12x1.75 Tapped Hole1[3] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: M12x1.75 Tapped Hole1[4] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Scale1 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: V3-CAP-168_Black and Yellow
In: Default Storey
PredefinedType: ELEMENT; Material: 0
