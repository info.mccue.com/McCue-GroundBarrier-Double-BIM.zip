Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MCCUE_BIM_GBD-K-RAL-120-307.IFC
Time: 2025-01-23T14:28:52
Written by: SwIFC
Made in: SolidWorks 2024

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: GB-C-RAL-120-307_2870 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: PE High Density
